# IAR project OSIO.ewp, settings and files
configuration Build (ARM, debug)
  General.OGChipSelectEditMenu: GD32F103x8 GD GD32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; _ANYID_GD32_; _ANYID_HSE12P00_; _ANYID_SM5003_; USE_FREE_RTOS; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ..\; ..\inc; ..\USB\inc; E:\AnyID\AnyID_Embedded\V1.1.0\STM32_lib_V3.3\startup; E:\AnyID\AnyID_Embedded\V1.1.0\STM32_lib_V3.3\inc; E:\AnyID\AnyID_Embedded\V1.1.0\AnyID_lib_V1.1.0\inc; ..\kernel\inc; ..\kernel\portable; ..\kernel\portable\iar; ..\kernel\portable\MemMang
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\kernel\portable; E:\AnyID\Git\OSIO\kernel\portable
  OBJCOPY.OOCOutputFile: OSIO.hex
  ILINK.IlinkOutputFile: OSIO.out
  ILINK.IlinkIcfFile: GD32F103x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../AnyID_Embedded/V1.1.0/STM32_lib_V3.3/startup/: system_stm32f10x.c
  group EWARMv5
    ../../../../AnyID_Embedded/V1.1.0/STM32_lib_V3.3/startup/: startup_stm32f10x_hd.s
  group Kernel
    ../kernel/src/: croutine.c event_groups.c list.c queue.c sbom.spdx stream_buffer.c tasks.c timers.c
  group Kernel/Portable/iar
    ../kernel/portable/iar/: port.c portasm.s portmacro.h
  group Kernel/Portable/MemMang
    ../kernel/portable/MemMang/: heap_4.c
  group Main
    ../: main.c stm32f10x_conf.h stm32f10x_it.c
  group StdPeriph_Driver
    ../../../../AnyID_Embedded/V1.1.0/STM32_lib_V3.3/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group User
    ../src/: AnyID_FRam.c AnyID_SM5003_AD.c AnyID_SM5003_AD_HL.c AnyID_SM5003_Device.c AnyID_SM5003_Fire_HL.c AnyID_SM5003_FRam.c AnyID_SM5003_FRam_HL.c AnyID_SM5003_R485.c AnyID_SM5003_R485_HL.c AnyID_SM5003_SysCfg.c AnyID_SM5003_SysTick_HL.c AnyID_SM5003_Water_HL.c AnyID_SM5003_WDG_HL.c AnyID_Tim_HL.c AnyID_Uart_Receive.c
    ../../../../AnyID_Embedded/V1.1.0/AnyID_lib_V1.1.0/src/: AnyID_Stdlib.c
